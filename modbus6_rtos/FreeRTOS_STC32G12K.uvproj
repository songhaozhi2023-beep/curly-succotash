# Keil uVision project FreeRTOS_STC32G12K.uvproj, settings and files
target FreeRTOS_STC32G_Demo (MCS-251)
  device: STC32G144K246-32Bit Series STC
  cpu: IRAM(0-0x3FFF) XRAM(0x10000-0x2FFFF) IROM(0xFC2800-0xFFFFFF) CLOCK(35000000)
  output: modbus6 +hex
  link misc: REMOVEUNUSED
  group FreeRTOS_V10.5.1
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group port
    ./FreeRTOS/portable/STC32G12K128/: portmacro.h portasm.h port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group library
    ./library/: STC32G_Delay.c STC32G_Clock.c
  group app
    ./: START251.A51 main.c mb_crc.c sensors.c screen.c
  group 使用说明
    ./: 使用说明.txt
