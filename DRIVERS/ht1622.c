#include "config.h"            // 包含系统配置头文件，定义基本数据类型和系统配置
#include "delay.h"             // 包含延时函数头文件，提供精确延时功能
#include "ht1622.h"            // 包含HT1622驱动头文件，定义HT1622显示驱动接口

// 定义HT1622控制引脚 - 定义HT1622 LCD控制器的控制引脚
sbit HT1622_CS   = P3^4;      // 位变量定义：HT1622片选信号，连接P3.4，用于选中设备
sbit HT1622_WR   = P3^6;      // 位变量定义：HT1622写时钟信号，连接P3.6，用于同步数据传输
sbit HT1622_DATA = P3^7;      // 位变量定义：HT1622数据信号，连接P3.7，用于传输数据

/*********************************************************
*  向HT1622发送一位数据 - 按照HT1622时序要求发送一位数据
*  dat bit0为要发送的位值 (0或1)
**********************************************************/
void HT1622_WriteBit(u8 dat)   // HT1622写一位数据函数定义
{
    if(dat & 0x01)             // 检查最低位是否为1，通过与操作判断最低位
        HT1622_DATA = 1;       // 如果是1，则数据线置高，发送逻辑1
    else
        HT1622_DATA = 0;       // 如果是0，则数据线置低，发送逻辑0

    delay_us(5);               // 数据建立时间，确保DATA稳定后再拉低WR (HT1622要求tSU≥1.67us@3V)
    HT1622_WR = 0;             // 写时钟信号置低，下降沿锁存数据
    delay_us(5);               // 写脉冲宽度，确保WR低电平满足HT1622时序要求(≥1.67us)
    HT1622_WR = 1;             // 写时钟信号置高，完成传输，上升沿完成传输
    delay_us(3);               // 保持时间，确保时序正确
}

/*********************************************************
*  HT1622数据传输开始 - 开始HT1622数据传输序列
**********************************************************/
void HT1622_Start(void)        // HT1622传输开始函数定义
{
    HT1622_CS = 0;             // 片选信号置低，选中HT1622，激活设备
    delay_us(5);               // CS建立时间，确保CS稳定后再传数据
}

/*********************************************************
*  HT1622数据传输结束 - 结束HT1622数据传输序列
**********************************************************/
void HT1622_Stop(void)         // HT1622传输结束函数定义
{
    HT1622_DATA = 1;           // ★ 恢复DATA为空闲高电平，否则总线空闲时DATA停留在最后一bit
    delay_us(1);
    HT1622_CS = 1;             // 片选信号置高，取消选中HT1622，结束传输
    delay_us(5);               // CS保持时间，确保HT1622正确识别帧结束
}

/*********************************************************
*  向HT1622写入命令 - 发送控制命令到HT1622
**********************************************************/
void HT1622_WriteCmd(u8 cmd)   // HT1622写命令函数定义
{
    u8 i;                     // 定义循环计数变量
    HT1622_Start();            // 开始传输，拉低片选信号
    HT1622_WriteBit(1);        // 发送写命令标识位，第一位为1表示写操作
    HT1622_WriteBit(0);        // 发送写命令标识位，第二位为0表示命令
    HT1622_WriteBit(0);        // 发送写命令标识位，第三位为0表示命令
    // 前三位"100"是HT1622命令格式标识
    
    for(i=0;i<8;i++)           // 发送8位命令数据，逐位传输 (MSB first)
        HT1622_WriteBit((cmd>>(7-i))&0x01);  // 逐位发送命令数据，从高位到低位 (bit7→bit0)

    HT1622_WriteBit(0);        // ★ 第9位 Don't Care 位 — HT1622 命令帧固定 12 位
                                // 如果缺少此位，整个命令无效，芯片不执行！
    HT1622_Stop();             // 结束传输，拉高片选信号
}

/*********************************************************
*  写入指定地址显示数据 - 在指定地址写入显示数据
**********************************************************/
void HT1622_WriteData(u8 addr, u8 dat) // HT1622写数据函数定义
{
    u8 i;                     // 定义循环计数变量
    HT1622_Start();            // 开始传输，拉低片选信号
    HT1622_WriteBit(1);        // 发送写数据标识位，第一位为1表示写操作
    HT1622_WriteBit(0);        // 发送写数据标识位，第二位为0表示数据
    HT1622_WriteBit(1);        // 发送写数据标识位，第三位为1表示数据
    // 前三位"101"是HT1622数据格式标识
    
    for(i=0;i<6;i++)           // 发送6位地址数据，HT1622使用6位地址 (MSB first)
        HT1622_WriteBit((addr>>(5-i))&0x01); // 逐位发送地址数据，从高位到低位 (bit5→bit0)
    
    for(i=0;i<4;i++)           // 发送4位数据（BCD编码的4位数字），HT1622显示4位数字 (MSB first)
        HT1622_WriteBit((dat>>(3-i))&0x01);  // 逐位发送数据，从高位到低位 (bit3→bit0)
    
    HT1622_Stop();             // 结束传输，拉高片选信号
}

/*********************************************************
*  清空HT1622所有显示RAM - 将所有显示RAM位置零
**********************************************************/
void HT1622_Clear(void)        // HT1622清屏函数定义
{
    u8 i;                     // 定义循环计数变量
    for(i=0; i<64; i++)        // HT1622有64个显示地址 (6-bit), 遍历所有地址
    {
        HT1622_WriteData(i, 0); // 清空每个地址的数据，将数据显示为0
    }
}

/*********************************************************
*  点亮HT1622所有显示RAM - 用于调试，确认段码映射
**********************************************************/
void HT1622_AllOn(void)        // HT1622全屏点亮函数定义
{
    u8 i;                     // 定义循环计数变量
    for(i=0; i<64; i++)        // HT1622 64个地址, COM0-COM7全部点亮
    {
        HT1622_WriteData(i, 0x0F); // 4位全1, 点亮所有SEG×COM交叉点
    }
}

/*********************************************************
*  HT1622 初始化配置 - 配置HT1622控制引脚并初始化设备
**********************************************************/
void HT1622_Init(void)         // HT1622初始化函数定义
{
    // 配置HT1622控制引脚为推挽输出模式，确保引脚能正确驱动HT1622
    // 仅配置用到的引脚：P3^4(CS), P3^6(WR), P3^7(DATA)
    P3M1 &= ~0xD0;             // 清除P3^4, P3^6, P3^7对应位，准备配置为推挽输出
    P3M0 |= 0xD0;              // 设置P3^4, P3^6, P3^7为推挽输出模式，提高驱动能力
    
    HT1622_CS   = 1;           // 初始化CS为高电平（未选中），确保设备初始为非激活状态
    HT1622_WR   = 1;           // 初始化WR为高电平，确保时钟信号初始为非激活状态
    HT1622_DATA = 1;           // 初始化DATA为高电平，确保数据信号初始为非激活状态
    delay_ms(10);              // 延时等待HT1622稳定，确保设备完全上电

    // ====== HT1622 完整初始化序列（Datasheet Recommended Power-On Flow） ======
    // 命令格式：ID(100) + 8-bit命令码，每个命令帧通过CS↑/↓隔离

    // 1. SYS_DIS  — 先关闭振荡器和LCD偏压，确保芯片处于已知初始状态
    HT1622_WriteCmd(HT1622_SYS_DIS);
    delay_ms(1);

    // 2. SYS_EN   — 启动系统振荡器（必须先于LCD_ON，LCD偏压发生器依赖系统时钟）
    HT1622_WriteCmd(HT1622_SYS_EN);
    delay_ms(1);              // 振荡器启动+稳定时间

    // 3. RC_256K  — 选择内部 256kHz RC 振荡器作为系统时钟源
    HT1622_WriteCmd(HT1622_RC_256K);

    // 4. NORMAL   — 退出 TEST 模式，进入正常工作模式
    // 关键！芯片上电后可能处于 TEST 模式，COM/SEG 不输出方波，必须显式退出
    HT1622_WriteCmd(HT1622_NORMAL);

    // 5. LCD_OFF  — 关闭LCD显示，准备最终配置
    HT1622_WriteCmd(HT1622_LCD_OFF);

    // 6. LCD_ON   — 开启LCD显示，偏压发生器和COM/SEG开始输出
    HT1622_WriteCmd(HT1622_LCD_ON);

    // 清屏后由Menu_Init/Menu_DisplayMainMenu显示主界面
    HT1622_Clear();
}