# Keil uVision project stc_uart_user_isp.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G144K246-32Bit Series STC
  cpu: IRAM(0-0x3FFF) XRAM(0x10000-0x2FFFF) IROM(0xFC2800-0xFFFFFF) CLOCK(35000000)
  output: stc_uart_user_isp +hex
  group Source Group 1
    ./src/: main.c iap.c dfu.c uart.c
