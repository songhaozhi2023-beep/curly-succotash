# Keil uVision project FreeRTOS_STC32G_Demo.uvproj, settings and files
target FreeRTOS_STC32G_Demo (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: FreeRTOS_Demo +hex
  link misc: REMOVEUNUSED
  group FreeRTOS
    ./Sources/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group port
    ./Sources/FreeRTOS/portable/STC32G12K128/: port.c portmacro.h portasm.h
    ./Sources/FreeRTOS/portable/MemMang/: heap_1.c
  group user
    ./: 请先阅读本使用方法.txt
    ./Sources/User/include/: FreeRTOSConfig.h
    ./Sources/User/: main.c adc.c adckey.c display.c rtc.c DebugPrintf.c putchar.c uart2_3.c MatrixKey.c ntc.c usb_cdc.c stc_usb_cdc_32g.LIB
